# Keil uVision project FATFS.uvprojx, settings and files
target FATFS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mainbootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --output --bin --output ./bin/mainbootlader.bin ./Obj/mainbootloader.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,
  c include: .\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Application;.\Driver;.\FATFS\src;.\CH376T;.\;.\LCD;.\RTC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Libraries/CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Libraries/StdPeriph_Driver_v3.5.0
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_fsmc.c stm32f10x_spi.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_usart.c
  group Driver
    ./Driver/: Gpio.c delay.c Nvic.c SystemClock.c bsp_key.c uart485.c
  group Application
    ./Application/: main.c stm32f10x_it.c IAP.h
  group CH376T
    ./CH376T/: FILE_SYS.C ch376.c spi2.c
  group RTC
    ./RTC/: rtc.c
  group LCD
    ./LCD/: font.c ILI9806G.c RA8875.c bsp_lcd.c fc12864-6.4.c 12864-NO_FONT.c word.c
  group readme
    ./: readme.txt
